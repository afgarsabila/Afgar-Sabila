** sch_path: ringoscilator/untitled.sch
**.subckt untitled
x1 net1 out GND ringosc3
V1 net1 GND 1.8
**.ends
.GLOBAL GND
.end
