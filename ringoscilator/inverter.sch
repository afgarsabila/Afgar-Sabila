** sch_path: ringoscilator/inverter.sch
**.subckt inverter
V1 in GND pulse(0 1.8 2NS 2NS 2NS 50NS 100NS 5)
V2 net1 GND 1.8
**.ends
.GLOBAL GND
.end
